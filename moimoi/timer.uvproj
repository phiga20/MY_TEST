# Keil uVision project timer.uvproj, settings and files
target timer (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: timer +hex
  c flags: Optimize=8 SizeSpeed=1
  group timerthanhghi
    ./: maintimer.c timer.c timer.h
